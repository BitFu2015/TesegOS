# Keil uVision project uvprj.uvprojx, settings and files
target STM32F0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uvprj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\STLib\CMSIS\Include;.\STLib\CMSIS\Device\Include;.\STLib\STM32F0xx_StdPeriph_Driver\inc;.\App;.\TesegOS\kernel;.\TesegOS\port
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x200000c4 size 0x1f3c
  group Header
    ./app/: stm32f0xx_conf.h
  group Source
    ./App/: main.c uart.c
  group STLib
    ./STLib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group CMSIS
    ./STLib/CMSIS/Device/Source/arm/: startup_stm32f030.s
    ./STLib/CMSIS/Device/Source/: system_stm32f0xx.c
  group TesegOS
    ./TesegOS/kernel/: uxos.c uxos.h
    ./TesegOS/port/: port.c port.h
